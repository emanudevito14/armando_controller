Commit message: Update arm_old.urdf.xacro

File: urdf/arm_old.urdf.xacro (robot description, xacro)
@@ -36,5 +36,5 @@
               <box size="0.025 0.055 0.025"/>
           </geometry>
-          <material name="black"/>
+          <material name="blu"/>
       </visual>
   </link>
